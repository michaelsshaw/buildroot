## package/hellomod/Config.in
```kconfig
config BR2_PACKAGE_HELLOMOD
	bool "hellomod"
	depends on BR2_LINUX_KERNEL
	help
		Linux Kernel Module Hello World
```
